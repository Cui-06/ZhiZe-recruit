# Keil uVision project Hardware_C1.uvproj, settings and files
target Hardware_C1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Hardware_C1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: Beep.c Key.c Led.c Motor.c Seg.c
